# Keil uVision project usbaudio.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usbaudio +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\src;.\games;.\display;.\usb;.\drivers;.\device;.\images
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\DMA.sct
  group Source Code
    ./drivers/: adcuser.c
    ./usb/: usbhw.c usbdesc.c usbcore.c usbuser.c usbdmain.c
    ./device/: core_cm3.c
    ./src/: main.c MainMenu.c PhotoGallery.c GameMenu.c MP3Player.c
    ./display/: GLCD_SPI_LPC1700.c
  group Pictures
    ./images/: worldcup.c messi.c barcelona.c
  group Game_Code
    ./games/: snake.c pong.c pong.h
software components: CMSIS:CORE 5.4.0, Board Support:A/D Converter 1.0.0, Board Support:Joystick 1.0.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
